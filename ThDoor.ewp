# IAR project ThDoor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: ThDoor.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: ThDoor.bin
  ILINK.IlinkOutputFile: ThDoor.out
  group (top)
    ./: __RCSwitch.c __RCSwitch.h analog.cpp analog.h eeprom.cpp eeprom.h EletroValvula.cpp EletroValvula.h hw.cpp hw.h main.cpp motor.cpp motor.h parametro.cpp parametro.h tempo.cpp tempo.h
